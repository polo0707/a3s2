KERNEL_DEVICETREE:append = "overlays/pwm0-gpio12.dtbo"
