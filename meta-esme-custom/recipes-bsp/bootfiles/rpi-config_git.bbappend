ENABLE_UART = "1"
RPI_EXTRA_CONFIG = ' \n \
	dtoverlay=pwm0-gpio12 \n \
	'
