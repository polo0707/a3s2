inherit externalsrc
EXTERNALSRC = "/home/jourdes/w/src/esme-pwm0-gpio12"
EXTERNALSRC_BUILD = "/home/jourdes/w/src/esme-pwm0-gpio12"

# initial_rev .: dbce52931c0d78da402e13f77d66253a86f9a869
